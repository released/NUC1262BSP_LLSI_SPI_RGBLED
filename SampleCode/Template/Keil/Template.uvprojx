# Keil uVision project Template.uvprojx, settings and files
target Template (6100001::V6.10.1::.\ARMCLANG)
  device: NUC1262SE4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC1262\Include;..\..\..\Library\StdDriver\inc;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1262.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
    ../../../Library/Device/Nuvoton/NUC1262/Source/ARM/: startup_NUC1262.s
  group User
    ../: main.c led_effect.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c timer.c pdma.c llsi.c spi.c
